#include <stdio.h>

// 计算最大值的辅助函数
int max(int a, int b) {
    return a > b ? a : b;
}

int main() {
    // 1. 定义题目中的数据
    int n = 5;              // 物品数量
    int W = 10;             // 背包总容量
    int w[] = { 0, 2, 3, 4, 5, 6 };  // 物品重量 (索引0占位，从1开始对应物品1-5)
    int v[] = { 0, 6, 5, 8, 10, 12 }; // 物品价值 (索引0占位)

    // 2. 初始化 dp 数组，dp[i][j] 代表前 i 个物品、容量为 j 时的最大价值
    int dp[6][11] = { 0 };

    // 3. 动态规划递推过程
    for (int i = 1; i <= n; i++) {       // 遍历每一个物品
        for (int j = 0; j <= W; j++) {   // 遍历每一个容量
            if (j >= w[i]) {
                // 如果装得下第 i 个物品，比较【不装】和【装】哪个价值更大
                dp[i][j] = max(dp[i - 1][j], dp[i - 1][j - w[i]] + v[i]);
            }
            else {
                // 如果当前容量装不下第 i 个物品，价值等于前 i-1 个物品的价值
                dp[i][j] = dp[i - 1][j];
            }
        }
    }

    // 4. 打印 DP 表格
    printf("背包容量 W = %d，物品数量 = %d\n", W, n);
    printf("--------------------------------------------------------------\n");
    printf("容量j |");
    for (int j = 0; j <= W; j++) {
        printf("%4d ", j);
    }
    printf("\n");
    printf("--------------------------------------------------------------\n");

    for (int i = 0; i <= n; i++) {
        printf("物品%d |", i);
        for (int j = 0; j <= W; j++) {
            printf("%4d ", dp[i][j]);
        }
        printf("\n");
    }
    printf("--------------------------------------------------------------\n");

    // 5. 输出最终答案
    printf("最终最大价值为: %d\n", dp[n][W]);

    return 0;
}